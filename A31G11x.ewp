# IAR project A31G11x.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: A31G111 ABOV A31G111
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCIncludePath2: source\App; source\Device; source\Drivers\Include; source\Drivers\Source; source\; 
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: A31G11x_RGB_LED.hex
  ILINK.IlinkOutputFile: A31G11x.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group App
    source/App/: A31G11x_it.c A31G11x_it.h A31G11x_PortInit.c A31G11x_SystemClock.c function.c function.h ks_Assignment.h ks_BITBAND.h main.c main.h main_conf.h
  group Device
    source/Device/: A31G11x.h startup_A31G11x_iar.s system_A31G11x.c system_A31G11x.h
  group Driver
    source/Drivers/Source/: A31G11x_hal_adc.c A31G11x_hal_crc.c A31G11x_hal_debug_frmwrk.c A31G11x_hal_fmc.c A31G11x_hal_i2cn.c A31G11x_hal_intc.c A31G11x_hal_lcd.c A31G11x_hal_pcu.c A31G11x_hal_pwr.c A31G11x_hal_scu.c A31G11x_hal_sculv.c A31G11x_hal_timer1n.c A31G11x_hal_timer2n.c A31G11x_hal_timer3n.c A31G11x_hal_uartn.c A31G11x_hal_usart1n.c A31G11x_hal_wdt.c A31G11x_hal_wt.c
